** sch_path: algorithm/xschem/SAR_SPICE/sar_logic_tb_spice.sch
* Copyright 2024 IHP PDK Authors
**.subckt sar_logic_tb_spice
V1 vdd GND 1.2
V3 En GND dc 0 ac 0 PULSE(1.2 0 0 1n 1n 30u 1m)
V6 Op GND dc 0 ac 0 PULSE(1.2 0 100u 1n 1n 500u 1m)
V2 rst GND dc 0 ac 0 PULSE(0 1.2 100u 1n 1n 10u 1m)
V5 Om GND dc 0 ac 0 PULSE(0 1.2 100u 1n 1n 500u 1m)
V4 clk GND dc 0 ac 0 PULSE(0 1.2 0 10p 10p 5u 10u)
x1 BN0 BN1 BN2 BN3 BN4 BN5 BN6 BN7 B0 B1 B2 B3 B4 B5 D0 D1 D2 D3 D4 D5 D6 D7 En Om Op GND vdd clk
+ rst sar_logic
**** begin user architecture code

.lib $::SG13G2_MODELS/cornerRES.lib res_typ_stat
.include [xschem get current_dirname]/sar_logic.spice
.include $PDK_ROOT/ihp-sg13g2/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice



.param temp=27
.control
set method=gear
set maxord=2

option gmin=1e-12
option rshunt=1e12
option reltol=1e-3
option vabstol=1u
option iabstol=1p
save all
tran 1u 200u
write sar_logic_tb_spice.raw
.endc





.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt



**** end user architecture code
**.ends
.GLOBAL GND
.end
