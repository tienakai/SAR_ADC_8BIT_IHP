v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sar_logic.sym} -190 320 0 0 {name=x1}
