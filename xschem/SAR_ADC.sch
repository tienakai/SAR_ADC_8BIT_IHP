v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1500 -830 1550 -830 {lab=bias}
N 1630 -730 1630 -690 {lab=gnd}
N 1260 -1130 1300 -1130 {lab=vdd}
N 1240 -1150 1240 -1130 {lab=gnd}
N 1240 -1150 1360 -1150 {lab=gnd}
N 1030 -530 1030 -510 {lab=BN_MSB}
N 1070 -530 1070 -510 {lab=BN6}
N 1100 -530 1100 -510 {lab=BN5}
N 1130 -530 1130 -510 {lab=BN4}
N 1160 -530 1160 -510 {lab=BN3}
N 1190 -530 1190 -510 {lab=BN2}
N 1220 -530 1220 -510 {lab=BN1}
N 1260 -530 1300 -530 {lab=vdd}
N 1240 -530 1240 -510 {lab=gnd}
N 1240 -510 1360 -510 {lab=gnd}
N 1030 -1160 1030 -1130 {lab=B_MSB}
N 1070 -1160 1070 -1130 {lab=B6}
N 1100 -1160 1100 -1130 {lab=B5}
N 1130 -1160 1130 -1130 {lab=B4}
N 1160 -1160 1160 -1130 {lab=B3}
N 1190 -1160 1190 -1130 {lab=B2}
N 1220 -1160 1220 -1130 {lab=B1}
N 850 -770 970 -770 {lab=#net1}
N 710 -820 710 -810 {lab=GND}
N 710 -700 710 -690 {lab=GND}
N 770 -820 770 -800 {lab=vdd}
N 770 -700 770 -680 {lab=vdd}
N 830 -820 830 -800 {lab=clk_samp}
N 630 -890 680 -890 {lab=vin_pos}
N 630 -770 680 -770 {lab=vin_neg}
N 1630 -970 1630 -930 {lab=vdd}
N 1680 -750 1680 -720 {lab=clk_comp}
N 830 -700 830 -680 {lab=clk_samp}
N 1830 -840 1880 -840 {lab=Op}
N 1830 -820 1880 -820 {lab=Om}
N 850 -890 970 -890 {lab=#net2}
N 1230 -990 1230 -950 {lab=vdd}
N 1230 -990 1300 -990 {lab=vdd}
N 1230 -1010 1230 -990 {lab=vdd}
N 1300 -1130 1300 -990 {lab=vdd}
N 1200 -1010 1200 -950 {lab=#net3}
N 1170 -1010 1170 -950 {lab=#net4}
N 1140 -1010 1140 -950 {lab=#net5}
N 1110 -1010 1110 -950 {lab=#net6}
N 1080 -1010 1080 -950 {lab=#net7}
N 1050 -1010 1050 -950 {lab=#net8}
N 1020 -1010 1020 -950 {lab=#net9}
N 1020 -710 1020 -650 {lab=#net10}
N 1050 -710 1050 -650 {lab=#net11}
N 1080 -710 1080 -650 {lab=#net12}
N 1110 -710 1110 -650 {lab=#net13}
N 1140 -710 1140 -650 {lab=#net14}
N 1170 -710 1170 -650 {lab=#net15}
N 1200 -710 1200 -650 {lab=#net16}
N 1230 -680 1230 -650 {lab=vdd}
N 1230 -680 1300 -680 {lab=vdd}
N 1230 -710 1230 -680 {lab=vdd}
N 1300 -680 1300 -530 {lab=vdd}
N 1290 -890 1550 -890 {lab=CDAC_v+}
N 1290 -770 1550 -770 {lab=CDAC_v-}
N 605 -530 935 -530 {
lab=B1}
N 605 -510 935 -510 {lab=B2}
N 605 -490 935 -490 {lab=B3}
N 605 -470 935 -470 {lab=B4}
N 605 -450 935 -450 {lab=B5}
N 605 -430 935 -430 {lab=B6}
N 605 -410 935 -410 {lab=B_MSB}
N 605 -390 935 -390 {lab=BN1}
N 605 -370 935 -370 {lab=BN2}
N 605 -350 935 -350 {lab=BN3}
N 605 -330 935 -330 {lab=BN4}
N 605 -310 935 -310 {lab=BN5}
N 605 -290 935 -290 {lab=BN6}
N 605 -270 935 -270 {lab=BN_MSB}
N 605 -250 935 -250 {lab=D7}
N 605 -230 935 -230 {lab=D6}
N 605 -210 935 -210 {lab=D5}
N 605 -190 935 -190 {lab=D4}
N 605 -170 935 -170 {lab=D3}
N 605 -150 935 -150 {lab=D2}
N 605 -130 935 -130 {lab=D1}
N 605 -110 935 -110 {lab=D0}
N 1490 -1150 1510 -1150 {lab=Op}
N 1490 -1090 1510 -1090 {lab=Om}
N 1600 -1230 1600 -1200 {lab=vdd}
N 1600 -1040 1600 -1020 {lab=gnd}
N 1750 -1120 1760 -1120 {lab=clk_algo}
N 1750 -1120 1750 -1100 {lab=clk_algo}
N 1740 -1120 1750 -1120 {lab=clk_algo}
N 1750 -1040 1750 -1020 {lab=gnd}
N 1600 -1020 1750 -1020 {lab=gnd}
N 180 -360 210 -360 {lab=clk_algo}
N 270 -360 330 -360 {lab=#net17}
N 180 -340 210 -340 {lab=Op}
N 180 -320 210 -320 {lab=vdd}
N 180 -300 210 -300 {lab=Om}
N 180 -280 210 -280 {lab=clk_samp}
N 270 -340 330 -340 {lab=#net18}
N 270 -320 330 -320 {lab=#net19}
N 270 -300 330 -300 {lab=#net20}
N 270 -280 330 -280 {lab=#net21}
N 490 -110 550 -110 {lab=#net22}
N 490 -130 550 -130 {lab=#net23}
N 490 -150 550 -150 {lab=#net24}
N 490 -170 550 -170 {lab=#net25}
N 490 -190 550 -190 {lab=#net26}
N 490 -210 550 -210 {lab=#net27}
N 490 -230 550 -230 {lab=#net28}
N 490 -250 550 -250 {lab=#net29}
N 490 -270 550 -270 {lab=#net30}
N 490 -290 550 -290 {lab=#net31}
N 490 -310 550 -310 {lab=#net32}
N 490 -330 550 -330 {lab=#net33}
N 490 -350 550 -350 {lab=#net34}
N 490 -370 550 -370 {lab=#net35}
N 490 -390 550 -390 {lab=#net36}
N 490 -410 550 -410 {lab=#net37}
N 490 -430 550 -430 {lab=#net38}
N 490 -450 550 -450 {lab=#net39}
N 490 -470 550 -470 {lab=#net40}
N 490 -490 550 -490 {lab=#net41}
N 490 -510 550 -510 {lab=#net42}
N 490 -530 550 -530 {lab=#net43}
C {devices/lab_pin.sym} 185 -280 2 1 {name=p2 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 1300 -1130 2 0 {name=p12 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 185 -340 2 1 {name=p3 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 185 -320 2 1 {name=p13 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 185 -300 2 1 {name=p14 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 1880 -840 2 0 {name=p36 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 1880 -820 2 0 {name=p37 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 1300 -530 0 1 {name=p38 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1030 -1160 1 0 {name=p40 sig_type=std_logic lab=B_MSB}
C {devices/lab_pin.sym} 1100 -1160 1 0 {name=p41 sig_type=std_logic lab=B5}
C {devices/lab_pin.sym} 1190 -1160 1 0 {name=p42 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 1160 -1160 1 0 {name=p43 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 1130 -1160 1 0 {name=p44 sig_type=std_logic lab=B4}
C {devices/lab_pin.sym} 1220 -1160 1 0 {name=p46 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 1070 -1160 1 0 {name=p45 sig_type=std_logic lab=B6}
C {devices/lab_pin.sym} 1030 -510 1 1 {name=p48 sig_type=std_logic lab=BN_MSB}
C {devices/lab_pin.sym} 1100 -510 1 1 {name=p49 sig_type=std_logic lab=BN5}
C {devices/lab_pin.sym} 1190 -510 1 1 {name=p50 sig_type=std_logic lab=BN2}
C {devices/lab_pin.sym} 1160 -510 1 1 {name=p51 sig_type=std_logic lab=BN3}
C {devices/lab_pin.sym} 1130 -510 1 1 {name=p52 sig_type=std_logic lab=BN4}
C {devices/lab_pin.sym} 1220 -510 1 1 {name=p53 sig_type=std_logic lab=BN1}
C {devices/lab_pin.sym} 1070 -510 1 1 {name=p54 sig_type=std_logic lab=BN6}
C {devices/lab_pin.sym} 935 -430 0 1 {name=p55 sig_type=std_logic lab=B6}
C {devices/lab_pin.sym} 935 -410 0 1 {name=p56 sig_type=std_logic lab=B_MSB}
C {devices/lab_pin.sym} 935 -470 0 1 {name=p57 sig_type=std_logic lab=B4}
C {devices/lab_pin.sym} 935 -530 0 1 {name=p58 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 935 -510 0 1 {name=p59 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 935 -490 0 1 {name=p60 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 935 -450 0 1 {name=p62 sig_type=std_logic lab=B5}
C {devices/lab_pin.sym} 935 -270 0 1 {name=p1 sig_type=std_logic lab=BN_MSB}
C {devices/lab_pin.sym} 935 -310 0 1 {name=p6 sig_type=std_logic lab=BN5}
C {devices/lab_pin.sym} 935 -370 0 1 {name=p7 sig_type=std_logic lab=BN2}
C {devices/lab_pin.sym} 935 -350 0 1 {name=p15 sig_type=std_logic lab=BN3}
C {devices/lab_pin.sym} 935 -330 0 1 {name=p16 sig_type=std_logic lab=BN4}
C {devices/lab_pin.sym} 935 -390 0 1 {name=p18 sig_type=std_logic lab=BN1}
C {devices/lab_pin.sym} 935 -290 0 1 {name=p19 sig_type=std_logic lab=BN6}
C {gnd.sym} 710 -810 0 1 {name=l3 lab=GND}
C {gnd.sym} 710 -690 0 1 {name=l4 lab=GND}
C {devices/lab_pin.sym} 770 -800 2 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1630 -970 2 0 {name=p65 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1680 -720 2 0 {name=p66 sig_type=std_logic lab=clk_comp}
C {iopin.sym} 935 -230 0 0 {name=p67 lab=D6}
C {iopin.sym} 935 -210 0 0 {name=p28 lab=D5}
C {iopin.sym} 935 -190 0 0 {name=p29 lab=D4}
C {iopin.sym} 935 -170 0 0 {name=p30 lab=D3}
C {iopin.sym} 935 -150 0 0 {name=p31 lab=D2}
C {iopin.sym} 935 -130 0 0 {name=p32 lab=D1}
C {iopin.sym} 935 -110 0 0 {name=p33 lab=D0}
C {devices/lab_pin.sym} 830 -800 2 0 {name=p22 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 770 -680 2 0 {name=p21 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 830 -680 2 0 {name=p23 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 1330 -890 3 1 {name=p74 sig_type=std_logic lab=CDAC_v+}
C {devices/lab_pin.sym} 1330 -770 1 1 {name=p73 sig_type=std_logic lab=CDAC_v-}
C {iopin.sym} 935 -250 0 0 {name=p4 lab=D7}
C {devices/lab_pin.sym} 180 -360 2 1 {name=p27 sig_type=std_logic lab=clk_algo}
C {devices/lab_pin.sym} 1490 -1150 2 1 {name=p9 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 1490 -1090 2 1 {name=p11 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 1600 -1230 2 1 {name=p34 sig_type=std_logic lab=vdd}
C {capa.sym} 1750 -1070 0 0 {name=C3
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_pin.sym} 1760 -1120 2 0 {name=p35 sig_type=std_logic lab=clk_algo}
C {switch_array.sym} 1130 -590 0 0 {name=x7}
C {switch_array.sym} 1130 -1070 2 1 {name=x4}
C {C-DAC.sym} 1120 -770 0 0 {name=x5}
C {C-DAC.sym} 1120 -890 2 1 {name=x2}
C {nand_gate.sym} 1660 -1110 0 0 {name=x8}
C {sar_logic.sym} 410 -320 0 0 {name=adut
dut=dut
d_cosim_model= d_cosim
model=./sar_logic.so}
C {adc_bridge1.sym} 240 -360 0 0 {name=A1
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.4
in_high=0.6
}
C {part_2_digital_comps/algorithm/xschem/adc_bridge1.sym} 240 -340 0 0 {name=A2
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.4
in_high=0.6
}
C {part_2_digital_comps/algorithm/xschem/adc_bridge1.sym} 240 -320 0 0 {name=A3
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.4
in_high=0.6
}
C {part_2_digital_comps/algorithm/xschem/adc_bridge1.sym} 240 -300 0 0 {name=A4
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.4
in_high=0.6
}
C {part_2_digital_comps/algorithm/xschem/adc_bridge1.sym} 240 -280 0 0 {name=A5
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.4
in_high=0.6
}
C {dac_bridge1.sym} 580 -530 0 0 {name=A6
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -510 0 0 {name=A7
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 580 -490 0 0 {name=A8
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 580 -470 0 0 {name=A9
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -450 0 0 {name=A10
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -430 0 0 {name=A11
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -410 0 0 {name=A12
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -390 0 0 {name=A13
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -370 0 0 {name=A14
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -350 0 0 {name=A15
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -330 0 0 {name=A16
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -310 0 0 {name=A17
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -290 0 0 {name=A18
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -270 0 0 {name=A19
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -250 0 0 {name=A20
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -230 0 0 {name=A21
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -210 0 0 {name=A22
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -190 0 0 {name=A23
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -170 0 0 {name=A24
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -150 0 0 {name=A25
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -130 0 0 {name=A26
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {part_2_digital_comps/algorithm/xschem/dac_bridge1.sym} 580 -110 0 0 {name=A27
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {bootstrap_switch.sym} 750 -890 0 0 {name=x1}
C {bootstrap_switch.sym} 750 -770 0 0 {name=x6}
C {dynamic_comparator.sym} 1700 -830 0 0 {name=x3}
C {ipin.sym} 630 -890 0 0 {name=p39 lab=vin_pos}
C {ipin.sym} 630 -770 0 0 {name=p25 lab=vin_neg}
C {iopin.sym} 450 -1100 0 0 {name=p8 lab=vdd
}
C {iopin.sym} 450 -1060 0 0 {name=p47 lab=gnd
}
C {ipin.sym} 1500 -830 0 0 {name=p26 lab=bias
}
C {ipin.sym} 400 -1100 0 0 {name=p5 lab=clk_comp
}
C {ipin.sym} 400 -1070 0 0 {name=p61 lab=clk_samp
}
C {devices/lab_pin.sym} 1360 -1150 0 1 {name=p10 sig_type=std_logic lab=gnd
}
C {devices/lab_pin.sym} 1630 -690 0 1 {name=p17 sig_type=std_logic lab=gnd
}
C {devices/lab_pin.sym} 1600 -1020 0 0 {name=p24 sig_type=std_logic lab=gnd
}
C {devices/lab_pin.sym} 1360 -510 0 1 {name=p63 sig_type=std_logic lab=gnd
}
